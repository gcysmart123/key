# Keil uVision project 按键中断.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 按键中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51
    ./按键中断vs/: delay.c display.c key.c main.c timer_0.c
